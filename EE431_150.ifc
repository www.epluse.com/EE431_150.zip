Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Mon Aug 10 15:51:26 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE431_150
In: Default Storey
PTC_Identity Data - DEVICENAME: Duct / Immersion Temperature Sensor; ENCLOSUREDESIGNSTANDARD: Cover: light grey RAL7035; housing: E+E green RAL6018; ENCLOSUREDIMENSIONS: WxHxD = 80.8x55.3x39.5 mm (3.2x2.2x1.6"); ENCLOSUREMATERIAL: Polycarbonate / US approval UL94V-0 / IP65 / NEMA 4; MEASURAND1: Temperature; Measuring range -40…+110 / 150 °C (-40…230 / 302 °F); OUTPUT1: Analogue voltage / current; 0-10 V / 4-20 mA; SUPPLY: 15-35 V DC or 24 V AC ±20%; OUTPUT2: Digital interface; RS485 with Modbus RTU or BACnet MS/TP; VOLUME: 165883; SURFACE_AREA: 21768.8; MASS: 165883; DENSITY: 1; CENTRE_OF_GRAVITY_X: 2.0543; CENTRE_OF_GRAVITY_Y: -4.4115; CENTRE_OF_GRAVITY_Z: -0.7186
